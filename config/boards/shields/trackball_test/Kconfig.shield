## config/boards/shields/trackball_test/Kconfig.shield
```kconfig
config SHIELD_TRACKBALL_TEST
    def_bool $(shields_list_contains,trackball_test)
```
